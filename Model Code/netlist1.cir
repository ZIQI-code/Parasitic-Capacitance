** Design1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: zq001
* Mon, Nov 16, 2020 12:58:45
*

*## Multisim Instrument XNA1 ##*
XNA1 21 19 XXNA1_462682944

*## Multisim Component C19 ##*
cC19 13 17 1e-006

*## Multisim Component C18 ##*
cC18 9 13 1e-006

*## Multisim Component C17 ##*
cC17 4 9 1e-006

*## Multisim Component C5 ##*
cC5 3 4 1e-006

*## Multisim Component C16 ##*
cC16 15 19 1e-006

*## Multisim Component C15 ##*
cC15 11 15 1e-006

*## Multisim Component C14 ##*
cC14 5 11 1e-006

*## Multisim Component C13 ##*
cC13 7 5 1e-006

*## Multisim Component C2 ##*
cC2 2 7 1e-006

*## Multisim Component R10 ##*
rR10 17 22 1000 vresR10
.model vresR10 r(  )

*## Multisim Component L11 ##*
lL11 22 19 0.001

*## Multisim Component C12 ##*
cC12 17 19 1e-006

*## Multisim Component R9 ##*
rR9 15 20 1000 vresR9
.model vresR9 r(  )

*## Multisim Component L10 ##*
lL10 20 17 0.001

*## Multisim Component C11 ##*
cC11 15 17 1e-006

*## Multisim Component R8 ##*
rR8 13 18 1000 vresR8
.model vresR8 r(  )

*## Multisim Component L9 ##*
lL9 18 15 0.001

*## Multisim Component C10 ##*
cC10 13 15 1e-006

*## Multisim Component R7 ##*
rR7 11 16 1000 vresR7
.model vresR7 r(  )

*## Multisim Component L8 ##*
lL8 16 13 0.001

*## Multisim Component C9 ##*
cC9 11 13 1e-006

*## Multisim Component R6 ##*
rR6 9 14 1000 vresR6
.model vresR6 r(  )

*## Multisim Component L7 ##*
lL7 14 11 0.001

*## Multisim Component C8 ##*
cC8 9 11 1e-006

*## Multisim Component R5 ##*
rR5 5 12 1000 vresR5
.model vresR5 r(  )

*## Multisim Component L6 ##*
lL6 12 9 0.001

*## Multisim Component C7 ##*
cC7 5 9 1e-006

*## Multisim Component R4 ##*
rR4 4 10 1000 vresR4
.model vresR4 r(  )

*## Multisim Component L5 ##*
lL5 10 5 0.001

*## Multisim Component C6 ##*
cC6 4 5 1e-006

*## Multisim Component R3 ##*
rR3 7 8 1000 vresR3
.model vresR3 r(  )

*## Multisim Component L3 ##*
lL3 8 4 0.001

*## Multisim Component C4 ##*
cC4 7 4 1e-006

*## Multisim Component L4 ##*
lL4 21 2 0.001

*## Multisim Component R2 ##*
rR2 3 6 1000 vresR2
.model vresR2 r(  )

*## Multisim Component L2 ##*
lL2 6 7 0.001

*## Multisim Component C3 ##*
cC3 3 7 1e-006

*## Multisim Component R1 ##*
rR1 2 1 1000 vresR1
.model vresR1 r(  )

*## Multisim Component L1 ##*
lL1 1 3 0.001

*## Multisim Component C1 ##*
cC1 2 3 1e-006

.subckt XXNA1_462682944 1 2
V1 5 0 AC 2.0
R1 5 1 50.000
V2 6 0 AC 0.0
R2 6 2 50.000
.ends
